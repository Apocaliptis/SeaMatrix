# IAR project Matrix.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; Libraries\STM8S_StdPeriph_Driver\inc; Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: matrix.c
  group SeaBattle
    ./: computer.c field.c game.c human.c shipPlacer.c stringOperations.c
  group STM8_TouchSensing_Driver
    Libraries/STM8_TouchSensing_Driver/src/: STM8_TSL_RC_API.c STM8_TSL_RC_IODriver.c STM8_TSL_RC_MultiChannelKey.c STM8_TSL_RC_Services.c STM8_TSL_RC_SingleChannelKey.c STM8_TSL_RC_TimerDriver.c
  group STM8S_StdPeriph_Driver
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
